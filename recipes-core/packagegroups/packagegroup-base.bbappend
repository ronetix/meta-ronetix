# remove baucase of conflict with Laird firmware
	
#RDEPENDS_packagegroup-base-wifi_remove = "wireless-regdb-static"
