FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

RDEPENDS:${PN}:append = " adwaita-icon-theme adwaita-icon-theme-cursors"
